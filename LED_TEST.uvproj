# Keil uVision project LED_TEST.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LED_TEST +hex
  c flags: Optimize=8 SizeSpeed=1
  group SRC
    ./SRC/: LED_TEST.C
    ./: STARTUP.A51
  group RTX51
    ./RTX51/: Conf_tny.A51
  group DEV
    ./DEV/: led_display.h led_display_cfg.h led_display.c
